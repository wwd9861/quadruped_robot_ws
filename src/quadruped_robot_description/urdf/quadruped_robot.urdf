Commit message: add ik

File: src/quadruped_robot_description/urdf/quadruped_robot.urdf (robot description, URDF)
Before this commit: robot quadruped_robot, 6 links, 5 joints
Links:
- link leg_1: mass 0.8145141492777322 -> 0.8145141492777319
